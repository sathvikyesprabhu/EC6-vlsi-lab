* nmos characteristics
.include ./t14y_tsmc_025_level3.txt

* NETLIST
vd out d dc 0
m1 d g 0 0 cmosn l=2.5u w=10u
vcap out cap dc 0
cl cap 0 0.5p
v_dd vdd 0 dc 5
vg g 0 dc 5 pulse(0 5 0 1n 1n 10n 20n)

* V n+ n- PULSE(V1 V2 TD TR TF PW PER)
m2 vdd vdd d 0 cmosn l=2.5u w=10u
.control
  * Vary w of driver
  foreach tr_new 0.1n 0.2n 0.3n 0.4n
    dc vg 0 5 0.01
    alter @vg[pulse]=[ 0 5 0 $tr_new 1n 10n 20n ]
    print $tr_new
    run

    * DC measurements
    meas dc vol min d
    meas dc voh max d
    let v90 = voh - 0.1 * (voh-vol)
    let v10 = vol + 0.1 * (voh-vol)
    let v50 = voh - 0.5 * (voh-vol)

    * transient response
    tran 0.1n 40n

    * transient measurements
    meas tran trise trig d val=dc.v10 rise=2 targ d val=dc.v90 rise=2
    meas tran tfall trig d val=dc.v90 fall=1 targ d val=dc.v10 fall=1
    meas tran tphl trig g val=dc.v50 rise=1 targ d val=dc.v50 fall=1
    meas tran tplh trig g val=dc.v50 fall=1 targ d val=dc.v50 rise=1
    let td = 0.5 * (tphl + tplh)
    print td
    let power = -5 * (v_dd#branch)
    meas tran pavg AVG power from=0n to=40n
*    plot (tran1.d) (g)
  end
  plot (dc1.d) (dc2.d) (dc3.d) (dc4.d)
*   plot (tran1.d) (tran2.d) (tran3.d) (tran4.d) (g)
  plot (-5*tran1.v_dd#branch) (-5*tran2.v_dd#branch) (-5*tran3.v_dd#branch) (-5*tran4.v_dd#branch)
  plot (0.5*0.5p*tran1.d*tran1.d) (0.5*0.5p*tran2.d*tran2.d) (0.5*0.5p*tran3.d*tran3.d) (0.5*0.5p*tran4.d*tran4.d)
.endc
