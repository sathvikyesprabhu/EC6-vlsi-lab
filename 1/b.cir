* nmos characteristics

* include the model file
.include ./t14y_tsmc_025_level3.txt

* netlist
* m_instance_name drain_node gate_node source_node bulk_substrate_node model_name L=length W=width
m1 vdd in 0 0 cmosn l=250n w=500n

* power sources
* v_instance_name posive_node negative_node value
v_dd vdd 0 3.3
v_in in 0 3.3

.control
  foreach wid 4u 7u 10u 20u
    dc v_in 0 3.3 0.1
    alter m1 w = $wid

  end
  plot (-dc1.v_dd#branch) (-dc2.v_dd#branch) (-dc3.v_dd#branch) (-dc4.v_dd#branch)

  foreach wid 4u 7u 10u 20u
    dc v_dd 0 3.3 0.1
    alter m1 w = $wid

  end

  plot (-dc5.v_dd#branch) (-dc6.v_dd#branch) (-dc7.v_dd#branch) (-dc8.v_dd#branch)
.endc
