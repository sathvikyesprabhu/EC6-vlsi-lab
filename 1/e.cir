* nmos characteristics

* include the model file
.include ./t14y_tsmc_025_level1.txt

* netlist
* m_instance_name drain_node gate_node source_node bulk_substrate_node model_name L=length W=width
m1 vdd in 0 0 ritsubn1 l=1u w=0.5u

* power sources
* v_instance_name posive_node negetive_node value
v_dd vdd 0 3.3
v_in in 0 3.3

.control
  foreach lambda_new 0.01 0.03 0.08 0.1
    dc v_in 0 3.3 0.1
    altermod m1 LAMBDA = $lambda_new
    run
  end

  plot (-dc1.v_dd#branch) (-dc2.v_dd#branch) (-dc3.v_dd#branch) (-dc4.v_dd#branch)
.endc

.control
  foreach lambda_new 0.01 0.03 0.08 0.1
    dc v_dd 0 3.3 0.1
    altermod m1 LAMBDA = $lambda_new
    run
  end

  plot (-dc5.v_dd#branch) (-dc6.v_dd#branch) (-dc7.v_dd#branch) (-dc8.v_dd#branch)
.endc
